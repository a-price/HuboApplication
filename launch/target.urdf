Commit message: Punching Bag Works.

File: launch/target.urdf (robot description, URDF)
Before this commit: robot demoTarget, 1 links, 0 joints
Links:
- link target_object: geometry visual sphere radius=0.025
